require u-boot.inc

# v2010.06-3 tag -> fc138475d1dda9decfb3bb2ad7f1c16225185e21
SRCREV = "fc138475d1dda9decfb3bb2ad7f1c16225185e21"
PR = "r0"

LIC_FILES_CHKSUM = "file://COPYING;md5=4c6cde5df68eff615d36789dc18edd3b"

